# Keil uVision project Project.uvproj, settings and files
target VC3101 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1
  c define: STM32F4XX,  USE_STDPERIPH_DRIVER
  c include: ..\..\App;..\..\Bsp;..\..\HardWareLib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\HardWareLib\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Components\RTOS\include;..\..\Components\RTOS\libcpu\arm\common;..\..\Components\RTOS\libcpu\arm\cortex-m4;..\..\Components\finsh;..\..\Components\GUI\emWin\Config;..\..\Components\GUI\emWin\GUI_X;..\..\Components\GUI\emWin\Include;..\..\Components\fatfs\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../App/: application.c startup.c stm32f4xx_it.c FramewinDLG.c
  group Bsp
    ../../Bsp/: board.c serial.c usart.c bsp_led.c bsp_key.c bsp_lcd_syb.c bsp_lcd_syb_gdi.c bsp_sdio_sd.c
  group RVMDK
    ../../HardWareLib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../../HardWareLib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../HardWareLib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CORTEX-M4
    ../../Components/RTOS/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../Components/RTOS/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Kernel
    ../../Components/RTOS/RT-Thread/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../../Components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group GUI_Driver
    ../../Components/GUI/emWin/DisplayDriver/: GUIDRV_Template.c
  group GUI_X
    ../../Components/GUI/emWin/GUI_X/: GUI_X_Touch.c GUI_X_RTT.c
  group GUI_Config
    ../../Components/GUI/emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI_Lib
    ../../Components/GUI/emWin/GUILib/: emWin_522_Keil460_M3_LE.lib
  group Form
    ../../App/Form/: Form_MainCodes.c Form_MainEvents.c
  group GUI_Font_HZ
    ../../Components/GUI/emWin/FontHZ/: GUI_Get_UTF8Data_FormFlash.c GUI_UC_EncodeNone.c
  group GUI_HANZI
    ../../Components/GUI/emWin/HanZi/: GUI_Font12.c GUI_Font16.c GUI_Font24.c GUI_Font48.c
  group FatFS
    ../../Components/fatfs/src/: diskio.c ff.c diskio.h ff.h ffconf.h integer.h
